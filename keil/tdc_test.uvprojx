# Keil uVision project tdc_test.uvprojx, settings and files
target max35104evkit2_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MAX32625 Maxim
  pack: Maxim.MAX32625.0.0.0-2.alpha
  cpu: IRAM(0x20000000,0x00028000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tdc_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=MAX32625 TARGET_REV=0x4132 MAX35104 DEBUG_BUILD ARM_MATH_CM4 BOARD_MAX35104EVKIT2
  c misc: --gnu
  c include: ..;..\board\max35104evkit2_max32625mbed\csl\CMSIS\Include;..\board\max35104evkit2_max32625mbed\csl\CMSIS\Device\Maxim\MAX32625\Include;..\board\max35104evkit2_max32625mbed\csl\PeriphDriver\Include;..\board\max35104evkit2_max32625mbed\max3510x;..\board\max35104evkit2_max32625mbed;..\matlab
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group src
    ../: main.c global.h uui.c uui.h flow.c flow.h transducer.c transducer.h config.c config.h
  group csl_max35104evkit2
    ../board/max35104evkit2_max32625mbed/csl/PeriphDriver/Source/: adc.c aes.c clkman.c crc.c flc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c maa.c mxc_assert.c mxc_lock.c mxc_sys.c nvic_table.c owm.c pmu.c prng.c pt.c rtc.c spim.c spis.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
    ../board/max35104evkit2_max32625mbed/csl/PeriphDriver/Include/: adc.h aes.h clkman.h crc.h flc.h gpio.h i2cm.h i2cs.h icc.h ioman.h lp.h maa.h mxc_assert.h mxc_config.h mxc_errors.h mxc_lock.h mxc_sys.h nvic_table.h owm.h pmu.h prng.h pt.h rtc.h spim.h spis.h spix.h tmr.h tmr_utils.h uart.h wdt.h wdt2.h
    ../board/max35104evkit2_max32625mbed/csl/CMSIS/Device/Maxim/MAX32625/Source/: system_max32625.c
    ../board/max35104evkit2_max32625mbed/csl/CMSIS/Device/Maxim/MAX32625/Source/ARM/: startup_max32625.s
  group board_max35104evkit2
    ../board/max35104evkit2_max32625mbed/: board.c board.h
  group max3510x_max35104evkit2
    ../board/max35104evkit2_max32625mbed/max3510x/: max3510x.c max3510x.h max3510x_regs.h
software components: CMSIS:DSP 1.5.1
